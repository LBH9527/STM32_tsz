# Keil uVision project project.uvproj, settings and files
target debug (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\..\..\Common\include;..\..\..\CMSIS;..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32_USB_OTG_Driver\inc;..\..\..\STM32_USB_HOST_Library\Core\inc;..\..\..\STM32_USB_Device_Library\Core\inc;..\..\..\BSP\inc;..\..\..\BSP;..\..\..\STM32_USB_Device_Library\Class\hid\inc;..\app;..\..\..\LCD\Fonts;..\..\..\RL-ARM\Driver;..\..\..\RL-ARM\Config;..\..\..\RL-ARM\RL-RTX\inc;..\user_config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c
    ../../../RL-ARM/Config/: Net_Config.c Net_Debug.c
  group common
    ../../../Common/source/: cortex_m.c am_rngbuf.c
    ../../../Common/include/: am_common.h
  group bsp
    ../../../BSP/: bsp.c bsp_userlib.c bsp_msg.c
    ../../../BSP/src/: bsp_bs18b20.c bsp_eeprom_24cxx.c bsp_gt9147.c bsp_i2c_gpio.c bsp_iwdg.c bsp_key.c bsp_lcd.c bsp_lcdtouch.c bsp_led.c bsp_printf.c bsp_rtc.c bsp_sdio_sd.c bsp_spi_bus.c bsp_spi_flash.c bsp_systick.c bsp_time_fun.c bsp_uart.c bsp_w25qxx_flash.c bsp_wv51216_sram.c lcd_nt35510.c
  group user_config
    ../user_config/: board_config.c board_config.h
  group fonts
    ../../../LCD/Fonts/: ascii.c fonts.c fontupd.c hz.c
  group platform
    ../PlatForm/: stm32f4xx_it.c startup_stm32f40_41xxx.s
  group cmsis
    ../../../CMSIS/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_exti.c
  group RL-TCPnet/Lib
    ../../../RL-ARM/RL-TCPnet/: TCPD_CM3.lib
  group RL-TCPnet/Driver
    ../../../RL-ARM/Driver/: ETH_STM32F4xx.c
