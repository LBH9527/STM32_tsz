# Keil uVision project explorer.uvprojx, settings and files
target debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: explorer
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\..\..\Common\include;..\..\..\CMSIS;..\..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32_USB_OTG_Driver\inc;..\..\..\STM32_USB_HOST_Library\Core\inc;..\..\..\STM32_USB_Device_Library\Core\inc;..\..\..\BSP\inc;..\..\..\BSP;..\..\..\STM32_USB_Device_Library\Class\customhid\inc;..\app;..\..\..\LCD\Fonts;..\app\usbd_hid;..\user_config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group common
    ../../../Common/include/: am_common.h
    ../../../Common/source/: am_rngbuf.c cortex_m.c
  group bsp
    ../../../BSP/: bsp.c bsp_userlib.c bsp_msg.c
    ../../../BSP/src/: bsp_uart.c bsp_beep.c bsp_bs18b20.c bsp_eeprom_24cxx.c bsp_gt9147.c bsp_i2c_gpio.c bsp_iwdg.c bsp_key.c bsp_lcd.c bsp_lcdtouch.c bsp_led.c bsp_printf.c bsp_rtc.c bsp_sdio_sd.c bsp_spi_bus.c bsp_spi_flash.c bsp_systick.c bsp_time_fun.c bsp_w25qxx_flash.c bsp_wv51216_sram.c lcd_nt35510.c
  group app
    ../app/: main.c usb_bsp.c
  group user_config
    ../user_config/: board_config.c board_config.h
  group fonts
    ../../../LCD/Fonts/: ascii.c fonts.c fontupd.c hz.c
  group platform
    ../PlatForm/: stm32f4xx_it.c startup_stm32f40_41xxx.s
  group cmsis
    ../../../CMSIS/: system_stm32f4xx.c
  group usbd_customhid
    ../app/usbd_hid/: usb_conf.h usb_it.c usbd_conf.h usbd_desc.c usbd_desc.h usbd_usr.c
  group STM32F4xx_StdPeriph_Driver
    ../../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_exti.c
  group STM32_USB_OTG_Driver
    ../../../STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32_USB_Device_Library/Core
    ../../../STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32_USB_Device_Library/Class/customhid
    ../../../STM32_USB_Device_Library/Class/customhid/src/: usbd_customhid_core.c
  group doc
    ../doc/: readme.txt
